# Keil uVision project exemplo_timer.uvproj, settings and files
target oin (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODC2 MDU_R515
  output: exemplo_timer +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: D:\Programas\Nordic Semiconductor\nRFgo SDK 2.3.0.10040\source_code\compiler\common;..\..\nrf24le1\nRF24LE1\libraries\nrf\source_code\hal\nrf24le1;D:\Programas\Nordic Semiconductor\nRFgo SDK 2.3.0.10040\nrf;D:\Programas\Nordic Semiconductor\nRFgo SDK 2.3.0.10040\source_code\hal
  group App
    ./: STARTUP.A51 exemplo_timer.c
  group hal
    D:/Programas/Nordic Semiconductor/nRFgo SDK 2.3.0.10040/source_code/hal/: hal_delay.c
