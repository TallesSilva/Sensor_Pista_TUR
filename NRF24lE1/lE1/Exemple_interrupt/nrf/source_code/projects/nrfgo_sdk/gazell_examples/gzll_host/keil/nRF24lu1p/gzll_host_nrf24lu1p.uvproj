# Keil uVision project gzll_host_nrf24lu1p.uvproj, settings and files
target gazell host (MCS-51)
  device: nRFLU1P-F16 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM (0x8000-0x87FF) CLOCK(16000000) MODC2
  output: gzll_host_nrf24lu1p +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\..\..\hal;..\..\..\..\..\..\hal\nrf24l01p;..\..\..\..\..\..\gazell\common;..\..\..\..\..\..\gazell\nrf24lu1;..\..\..\params;..\..\..\..\..\..\lib\crypt;..\..\..\..\..\..\lib\assertions;..\..\..\..\..\..\hal\nrf24lu1p;..\..\..\..\..\..\compiler\c51;..\..\..\..\..\..\compiler\common
  link misc: REMOVEUNUSED
  group app
    ../../: main.c
  group gzll
    ../../../../../../gazell/nrf24lu1/: gzll_timer_isr.c gzll_radio_isr.c gzll_mcu.c
    ../../../../../../gazell/common/: gzll.c
  group hal
    ../../../../../../hal/nrf24lu1p/: hal_nrf_hw.c hal_aes.c
    ../../../../../../hal/nrf24l01p/: hal_nrf.c
    ../../../../../../hal/: hal_delay.c
  group lib
    ../../../../../../lib/crypt/: lib_crypt_lu1.c lib_crypt.c
