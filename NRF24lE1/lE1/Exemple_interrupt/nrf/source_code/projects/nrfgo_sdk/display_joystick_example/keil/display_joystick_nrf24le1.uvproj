# Keil uVision project display_joystick_nrf24le1.uvproj, settings and files
target display_joystick (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODC2 MDU_R515
  output: display_joystick_nrf24le1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: NRF24LE1_48
  c include: ..\..\..\..\hal\nrf24le1;..\..\..\..\lib\display;..\..\..\..\hal;..\..\..\..\compiler\common;..\..\..\..\compiler\c51;..\..\..\..\lib\assertions\
  group app
    ../: main.c
  group hal
    ../../../../hal/: hal_delay.c
    ../../../../hal/nrf24le1/: hal_w2.c
  group lib
    ../../../../lib/display/: lib_display.c
