# Keil uVision project enhanced_shockburst_ptx_nrf24lu1p.uvproj, settings and files
target PTX (MCS-51)
  device: nRF24LU1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM (0x8000-0x87FF) CLOCK(16000000) MODC2
  output: enhanced_shockburst_ptx_nrf24lu1p +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: MCU_NRF24LU1P
  c include: ..\..\..\..\..\..\hal\nrf24lu1p;..\..\..\..\..\..\hal\nrf24l01p;..\..\..\..\..\..\hal;..\..\..\..\..\..\compiler\c51;..\..\..\..\..\..\compiler\common
  group App
    ../../: main.c
  group HAL
    ../../../../../../hal/nrf24lu1p/: hal_nrf_hw.c
    ../../../../../../hal/nrf24l01p/: hal_nrf.c
