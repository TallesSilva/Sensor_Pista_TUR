# Keil uVision project enhanced_shockburst_prx_nrf24le1.uvproj, settings and files
target PRX (MCS-51)
  device: nRFLU1P-F32 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) XRAM (0x8000-0x87FF) CLOCK(16000000) MODC2
  output: enhanced_shockburst_prx_nrf24le1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: MCU_NRF24LE1
  c include: ..\..\..\..\..\..\hal\nrf24le1;..\..\..\..\..\..\hal\nrf24l01p;..\..\..\..\..\..\hal;..\..\..\..\..\..\compiler\common;..\..\..\..\..\..\compiler\c51
  group App
    ../../: main.c
  group HAL
    ../../../../../../hal/nrf24le1/: hal_nrf_hw.c hal_clk.c
    ../../../../../../hal/nrf24l01p/: hal_nrf.c
