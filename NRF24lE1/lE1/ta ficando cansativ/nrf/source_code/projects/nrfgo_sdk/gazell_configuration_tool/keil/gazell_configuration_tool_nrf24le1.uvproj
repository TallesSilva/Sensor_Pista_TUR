# Keil uVision project gazell_configuration_tool_nrf24le1.uvproj, settings and files
target Gazell configuration tool (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODC2 MDU_R515
  output: gazell_configuration_tool +hex
  c flags: Optimize=8
  c define: GZLL_CRYPT_ENABLE,  ASSERT_ENABLE
  c include: ..\..\..\..\hal;..\..\..\..\hal\nrf24l01p;..\..\..\..\hal\nrf24le1;..\..\..\..\lib\assertions;..\..\..\..\lib\lib_crypt;..\..\..\..\gazell\nrf24le1;..\..\..\..\gazell\common;..\..\..\..\lib\display;..\..\..\..\compiler\common;..\..\..\..\compiler\c51;..\
  link misc: REMOVEUNUSED
  group Application
    ../: main.c
  group Gazell link layer
    ../../../../gazell/nrf24le1/: gzll_mcu.c gzll_radio_isr.c
    ../../../../gazell/common/: gzll.c
  group LIb
    ../../../../lib/display/: lib_display.c
    ../../../../lib/crypt/: lib_crypt_le1.c lib_crypt.c
  group HAL
    ../../../../hal/nrf24le1/: hal_aes.c hal_clk.c hal_nrf_hw.c hal_rng.c hal_rtc.c hal_w2.c
    ../../../../hal/nrf24l01p/: hal_nrf.c
    ../../../../hal/: hal_delay.c
