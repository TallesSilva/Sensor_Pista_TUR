# Keil uVision project adc_single_step_nrf24le1.uvproj, settings and files
target adc_single_step_mode (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODC2
  output: adc_single_step_nrf24le1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\..\hal\nrf24le1;..\..\..\..\..\hal;..\..\..\..\..\compiler\c51;..\..\..\..\..\compiler\common
  group App
    ../: main.c
  group HAL
    ../../../../../hal/nrf24le1/: hal_adc.c
