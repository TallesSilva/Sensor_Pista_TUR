# Keil uVision project ta tarde.uvproj, settings and files
target Target 1 (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODC2 MDU_R515
  output: ta tarde +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\nrf;.\nrf\source_code\compiler\common;.\nrf\source_code\hal;.\nrf\source_code\hal\nrf24le1
  group Source Group 1
    ./: oin.c
