# Keil uVision project interrupt.uvproj, settings and files
target Interrupt (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODC2 MDU_R515
  output: interrupt +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Exemple_interrupt\nrf;..\Exemple_interrupt\nrf\source_code\compiler\common;..\Exemple_interrupt\nrf\source_code\hal\nrf24le1;..\Exemple_interrupt\nrf\source_code\hal
  group APP
    ./: STARTUP.A51 interrupt.c
